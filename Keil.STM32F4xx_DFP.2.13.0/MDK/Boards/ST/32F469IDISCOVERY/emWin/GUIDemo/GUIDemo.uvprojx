# Keil uVision project GUIDemo.uvprojx, settings and files
target Debug (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F469NIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00050000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: GUIDemo
  c flags: Optim=2
  c define: HSE_VALUE=8000000 DATA_IN_ExtSDRAM TS_LANDSCAPE=1
  c misc: --diag_suppress=1035
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x50000
  group Source
    ./: main.c
    ./: GUIDemo.c
  group Documentation
    ./: Abstract.txt
target Release (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F469NIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: as above
  output: GUIDemo
  c flags: Optim=4
  c define: HSE_VALUE=8000000 DATA_IN_ExtSDRAM TS_LANDSCAPE=1
  c misc: --diag_suppress=1035
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x50000
software components: CMSIS:CORE 5.0.2, CMSIS:RTOS2:Keil RTX5 5.3.0, Board Support:Drivers:Basic I/O 1.0.0, Board Support:Drivers:SDRAM 1.0.0, Board Support:Drivers:Touch Screen 1.0.0, Board Support:Touchscreen 1.0.0, Board Support:emWin LCD 1.0.0, Device:STM32Cube Framework:Classic 1.7.4, Device:STM32Cube HAL:Common 1.6.0, Device:STM32Cube HAL:Cortex 1.6.0, Device:STM32Cube HAL:DMA 1.6.0, Device:STM32Cube HAL:DMA2D 1.6.0, Device:STM32Cube HAL:DSI 1.6.0, Device:STM32Cube HAL:GPIO 1.6.0, Device:STM32Cube HAL:I2C 1.6.0, Device:STM32Cube HAL:LTDC 1.6.0, Device:STM32Cube HAL:PWR 1.6.0, Device:STM32Cube HAL:RCC 1.6.0, Device:STM32Cube HAL:SDRAM 1.6.0, Device:STM32Cube HAL:SPI 1.6.0, Device:Startup 2.6.2, Graphics Display:32F469IDISCOVERY 1.0.2, Graphics:CORE 5.42.9, Graphics:Demo:AntialiasedText 5.42.9, Graphics:Demo:Automotive 5.42.9, Graphics:Demo:BarGraph 5.42.9, Graphics:Demo:Bitmap 5.42.9, Graphics:Demo:ColorBar 5.42.9, Graphics:Demo:Cursor 5.42.9, Graphics:Demo:Fading 5.42.9, Graphics:Demo:Framework 5.42.9, Graphics:Demo:Graph 5.42.9, Graphics:Demo:IconView 5.42.9, Graphics:Demo:ListView 5.42.9, Graphics:Demo:RadialMenu 5.42.9, Graphics:Demo:Skinning 5.42.9, Graphics:Demo:Speed 5.42.9, Graphics:Demo:TransparentDialog 5.42.9, Graphics:Demo:Treeview 5.42.9, Graphics:Demo:WashingMachine 5.42.9, Graphics:Input Device:Touchscreen 5.42.9
