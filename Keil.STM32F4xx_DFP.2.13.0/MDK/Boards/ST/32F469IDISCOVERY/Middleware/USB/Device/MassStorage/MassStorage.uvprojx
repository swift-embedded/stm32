# Keil uVision project MassStorage.uvprojx, settings and files
target Debug (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F469NIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00050000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: MassStorage
  c flags: Optim=2
  c define: HSE_VALUE=8000000
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20010000 size 0x40000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group Source
    ./: main.c MassStorage.c USBD_User_MSC_0.c
  group Documentation
    ./: Abstract.txt
target Release (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F469NIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: as above
  output: MassStorage
  c flags: Optim=4
  c define: HSE_VALUE=8000000
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x50000
software components: CMSIS:CORE 5.0.2, CMSIS:RTOS2:Keil RTX5 5.3.0, Compiler:Event Recorder 1.2.1, Compiler:I/O:File 1.2.1, File System:CORE 6.10.0, File System:Drive:Memory Card 6.10.0, USB:CORE 6.12.0, USB:CORE 6.12.0, USB:Device 6.12.0, USB:Device:MSC 6.12.0, CMSIS Driver:MCI 2.8, CMSIS Driver:USB Device:Full-speed 2.19, Device:STM32Cube Framework:Classic 1.7.4, Device:STM32Cube HAL:Common 1.6.0, Device:STM32Cube HAL:Cortex 1.6.0, Device:STM32Cube HAL:DMA 1.6.0, Device:STM32Cube HAL:GPIO 1.6.0, Device:STM32Cube HAL:PWR 1.6.0, Device:STM32Cube HAL:RCC 1.6.0, Device:STM32Cube HAL:SRAM 1.6.0, Device:Startup 2.6.2
